Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Numéro du projet
Time: 2019-12-09T21:31:55
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.6.0.0 - Interface alternative d'export 16.6.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Dec 09 21:31:55 2019 * Host: N08 * Database: C:\Users\N~1\AppData\Local\Temp\{60C5F4A6-B45B-4BA3-AA27-7906CAFDB6AE}\ifc * Database version: 5507 * Database creation date: Mon Dec 09 21:31:51 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Dec 09 21:31:52 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Dec 09 21:31:52 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Numéro du projet
LongName: Nom du projet; Phase: Etat du projet

# IfcSite, Default
RefLatitude: 48, 51, 23, 999633; RefLongitude: 2, 21, 3, 553905; RefElevation: 0 m
Autre - Adresse du projet: Entrer l'adresse ici; Catégorie: Informations sur le projet; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: Numéro du projet

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Autre - Catégorie: Informations sur le projet; Adresse du projet: Entrer l'adresse ici; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: Numéro du projet

# IfcBuildingStorey, Niveau 0
LongName: Niveau 0; Elevation: -1.94916e-14 m
Graphismes(Type) - Couleur: 12632256; Epaisseur des lignes: 1; Motif des lignes: Tiret point; Symbole: Marqueur de niveau - Point triangulaire: Marqueur de niveau - Point triangulaire; Valeur par défaut du symbole à l'extrémité 1: no; Valeur par défaut du symbole à l'extrémité 2: yes
Données d'identification(Type) - Nom du type: Ligne du Niveau
Contraintes(Type) - Base de l'élévation: Point de base du projet
Autre - Catégorie: Niveaux; Famille: Niveau: Ligne du Niveau; Famille et type: Niveau: Ligne du Niveau; ID du type: Niveau: Ligne du Niveau; Type: Niveau: Ligne du Niveau
Contraintes - Elévation: 0 m
Cotes - Hauteur de calcul: 0 m
Données d'identification - Etage de bâtiment: yes; Nom: Niveau 0; Structure: no
Autre(Type) - Catégorie: Niveaux; Nom de la famille: Niveau

# IfcBuildingElementProxy: HT23 RTJ PRO, Construction_Aerial-Equipment_Haulotte_HT-23-PRO_FR:HT23 RTJ PRO:567290
In: Niveau 0
Type - Classification: E10 Equipement (Uniformat); Material: Red, Black, Metal - Haulotte - Black, Metal - Haulotte - Grey, Haulotte, Metal - Haulotte - Yellow, Metal - Haulotte - White, Blue
Type - Autre(Type) - Catégorie: Equipement spécialisé; Energie: Thermal - KUBOTA engine; Masse Machine (CE): 13320 kg (25953 lbs); MT: no; Nom de la famille: Construction_Aerial-Equipment_Haulotte_HT-23-PRO_FR
Type - Données d'identification(Type) - Code d'assemblage: E10; Description: Performance et productivité exceptionnelles Très bonne enveloppe de travail Charge panier de 230 kg Double charge 230-450 kg (option) Confort de conduite et sentiment de sécurité Haulotte Activ'Shield Bar 2.0 (standard modèle PRO) Haulotte Activ'Lighting System pour un chargement/déchargement sécurisé en condition de faible luminosité (standard modèle PRO) Mouvements rapides, proportionnels et simultanés Rigidité de la flèche Coûts de maintenance et de fonctionnement réduits Haulotte Activ'Screen (diagnostic embarqué) Haulotte Stop Emission System : éteint / rallume le moteur automatiquement Facilité d’accès à tous les composants Panier modulaire, facile et rapide à réparer; Description de l'assemblage: Equipement; Fabricant: Haulotte; Modèle: HA23 RTJ PRO; Nom du type: HT23 RTJ PRO; Note d'identification: 11000; Numéro OmniClass: 23.15.99.00; Product data url: https://www.bimobject.com/haulotte/product/ht23-rtj-pro; Titre OmniClass: Other Utility and Transportation Construction Products; URL: http://www.haulotte.fr
Type - Données(Type) - Angle de Levage Pendulaire: 133° (+68°/-65°); Angle de Rotation Plateforme: 180° ( +90°/-90°); Angle de Rotation Tourelle: 360° continuous; Articulation Pendulaire: 2,15 m ( 7 ft); Capacité Maximum: 2 persons - 230 kg / Option : 3 persons - 450 kg ( 2 persons - 500 lbs / Option : 3 persons - 1000 lbs); Déport Arrière: 109 cm (3 ft 7 in); Déport Maximum: 18,3 m (60 ft 5 in); Devers: 5°; Dimensions Plateforme: 2.44 x 0.91 m (8ft x 3ft); Empattement: 2,5 m ( 8 ft 2 in); Garde au Sol: 34 cm (14 in); Hauteur de Transport: 3,3 m (10 ft 10 in); Hauteur Plateforme: 20,5 m (67 ft); Hauteur Repliée: 2,7 m (8 ft 11 in); Hauteur Travail: 22,5 m (73 ft); Largeur Hors Tout: 2,47 m ( 8 ft 1 in); Longueur de Transport: 7,8 m (25 ft 8 in); Longueur Hors Tout: 10,4 m (34 ft 3 in); Longueur Pendulaire: 2,15 m ( 7 ft 6,46 in); Pente Maximum: 40%; Pneus: Foam-filled tires 385/65 - 22,5; Point D'articulation: N/A; Pression Max au Sol: 12,5 daN/cm²; Rayon de Braquage Exterieur: 6,1 m ( 20 ft); Rayon de Braquage Interieur: 3,4 m (11 ft 2 in); Vitesse de Translation: 0,5-6,5 km/h (0,3-4 mph)
Type - Général(Type) - Edition number: 1
Pset_BuildingElementProxyCommon - Reference: HT23 RTJ PRO
Pset_ManufacturerTypeInformation - Manufacturer: Haulotte
Autre - A1: 0 deg; A2: 45 deg; A22: 135 deg; A4: 0 deg; Catégorie: Equipement spécialisé; Famille: Construction_Aerial-Equipment_Haulotte_HT-23-PRO_FR: HT23 RTJ PRO; Famille et type: Construction_Aerial-Equipment_Haulotte_HT-23-PRO_FR: HT23 RTJ PRO; ID du type: Construction_Aerial-Equipment_Haulotte_HT-23-PRO_FR: HT23 RTJ PRO; L2: 15.323 m; L CTRL: 15.323 m; Type: Construction_Aerial-Equipment_Haulotte_HT-23-PRO_FR: HT23 RTJ PRO; VJRA: -45 deg; WM: no
Construction - Abaque de Travail: no; Angle de Levage Flèche: 45 deg; Angle de Levage Pendulaire: -45 deg; Angle de Rotation Tourelle: 0 deg; Rayon de Braquage Exterieur: no; Rotation Panier: 0 deg; Sortie du Telescope: 15.323 m; Zone de Travail: no
Contraintes - Décalage: 0 m; Hôte: Niveau : Niveau 0; Niveau: Niveau: Niveau 0; Se déplace avec les éléments voisins: no
Cotes - Surface: 141.615 m2; Volume: 23.8504 m3
Graphismes - Marque: yes
Phase de construction - Phase de création: Nouvelle construction
