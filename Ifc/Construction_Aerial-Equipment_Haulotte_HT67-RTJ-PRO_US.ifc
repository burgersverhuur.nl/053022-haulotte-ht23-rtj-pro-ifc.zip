Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Numéro du projet
Time: 2019-12-09T21:33:17
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.6.0.0 - Interface alternative d'export 16.6.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Dec 09 21:33:17 2019 * Host: N08 * Database: C:\Users\N~1\AppData\Local\Temp\{02D131FA-F294-427C-B64A-9358B304E6BB}\ifc * Database version: 5507 * Database creation date: Mon Dec 09 21:33:13 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Dec 09 21:33:13 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Dec 09 21:33:13 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Numéro du projet
LongName: Nom du projet; Phase: Etat du projet

# IfcSite, Default
RefLatitude: 48, 51, 23, 999633; RefLongitude: 2, 21, 3, 553905; RefElevation: 0 m
Autre - Adresse du projet: Entrer l'adresse ici; Catégorie: Informations sur le projet; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: Numéro du projet

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Autre - Catégorie: Informations sur le projet; Adresse du projet: Entrer l'adresse ici; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: Numéro du projet

# IfcBuildingStorey, Niveau 0
LongName: Niveau 0; Elevation: -1.94916e-14 m
Graphismes(Type) - Couleur: 12632256; Epaisseur des lignes: 1; Motif des lignes: Tiret point; Symbole: Marqueur de niveau - Point triangulaire: Marqueur de niveau - Point triangulaire; Valeur par défaut du symbole à l'extrémité 1: no; Valeur par défaut du symbole à l'extrémité 2: yes
Données d'identification(Type) - Nom du type: Ligne du Niveau
Contraintes(Type) - Base de l'élévation: Point de base du projet
Autre - Catégorie: Niveaux; Famille: Niveau: Ligne du Niveau; Famille et type: Niveau: Ligne du Niveau; ID du type: Niveau: Ligne du Niveau; Type: Niveau: Ligne du Niveau
Contraintes - Elévation: 0 m
Cotes - Hauteur de calcul: 0 m
Données d'identification - Etage de bâtiment: yes; Nom: Niveau 0; Structure: no
Autre(Type) - Catégorie: Niveaux; Nom de la famille: Niveau

# IfcBuildingElementProxy: HT67 RTJ PRO, Construction_Aerial-Equipment_Haulotte_HT-67-PRO_US:HT67 RTJ PRO:567290
In: Niveau 0
Type - Classification: E10 Equipement (Uniformat); Material: Red, Metal - Haulotte - Black, Metal - Haulotte - Grey, Haulotte, Metal - Haulotte - Yellow, Metal - Haulotte - White, Blue
Type - Autre(Type) - Catégorie: Equipement spécialisé; Energy: Thermal - KUBOTA engine; Machine Weight: 13320 kg (25953 lbs); Nom de la famille: Construction_Aerial-Equipment_Haulotte_HT-67-PRO_US; TM: no
Type - Données d'identification(Type) - Code d'assemblage: E10; Description: Outstanding performance and productivity Very good working envelope Basket load 230 kg Double load 230-450 kg (optional) Driving comfort and sense of security Activ'Shield Bar 2.0 Haulotte (standard PRO model) Activ'Lighting System Haulotte for secure charging/discharging in low-light conditions (standard PRO model) Fast, proportional and simultaneous movements Boom stiffness Reduced maintenance and operating costs Haulotte Activ'Screen (on-board diagnostics) Haulotte Stop Emission System: turns the engine off / back on automatically Easy access to all components Modular basket, easy and quick to repair; Description de l'assemblage: Equipement; Fabricant: Haulotte; Modèle: HT67 RTJ PRO; Nom du type: HT67 RTJ PRO; Note d'identification: 11000; Numéro OmniClass: 23.15.99.00; Product data url: https://www.bimobject.com/haulotte/product/ht23-rtj-pro; Titre OmniClass: Other Utility and Transportation Construction Products; URL: http://www.haulotte-usa.com/
Type - Données(Type) - Articulating Jib: 2,15 m ( 7 ft); Drive Speed: 0,5-6,5 km/h (0,3-4 mph); Gradeability: 40%; Ground Clearance: 34 cm (14 in); Height - Storage / Transport: 3,3 m (10 ft 10 in); Height - Stowed: 2,7 m (8 ft 11 in); Horizontal Outreach: 18,3 m (60 ft 5 in); Jib Length: 2,15 m ( 7 ft 6,46 in); Lenght - Storage/Transport: 7,8 m (25 ft 8 in); Length - Stowed: 10,4 m (34 ft 3 in); Lift Capacity: 2 persons - 230 kg / Option : 3 persons - 450 kg ( 2 persons - 500 lbs / Option : 3 persons - 1000 lbs); Max Ground Pressure of Wheel on Paved Ground: 12,5 daN/cm²; Platform Height: 20,5 m (67 ft); Platform Rotation: 180° ( +90°/-90°); Platform Size: 2.44 x 0.91 m (8ft x 3ft); Tailswing: 109 cm (3 ft 7 in); Tires: Foam-filled tires 385/65 - 22,5; Turnable Rotation: 360° continuous; Turning Radius - Inside: 3,4 m (11 ft 2 in); Turning Radius - Outside: 6,1 m ( 20 ft); Up and Over Clearance: N/A; Vertical Jib Rotation Angle: 133° (+68°/-65°); Wheelbase: 2,5 m ( 8 ft 2 in); Width: 2,47 m ( 8 ft 1 in); Working Height: 22,5 m (73 ft)
Type - Général(Type) - Edition number: 1; Tilt: 5 deg
Pset_BuildingElementProxyCommon - Reference: HT67 RTJ PRO
Pset_ManufacturerTypeInformation - Manufacturer: Haulotte
Autre - A1: 0 deg; A2: 45 deg; A22: 135 deg; A4: 0 deg; Catégorie: Equipement spécialisé; Famille: Construction_Aerial-Equipment_Haulotte_HT-67-PRO_US: HT67 RTJ PRO; Famille et type: Construction_Aerial-Equipment_Haulotte_HT-67-PRO_US: HT67 RTJ PRO; ID du type: Construction_Aerial-Equipment_Haulotte_HT-67-PRO_US: HT67 RTJ PRO; L2: 15.323 m; L CTRL: 15.323 m; Type: Construction_Aerial-Equipment_Haulotte_HT-67-PRO_US: HT67 RTJ PRO; VJRA: -45 deg; WM: no
Construction - Boom Rotation Angle: 45 deg; Platform Rotation Angle: 0 deg; Reach Diagram: no; Telescopic Extend: 15.323 m; Turnable Rotation: 0 deg; Turning Radius: no; Vertical Jib Rotation Angle: -45 deg; Working Area: no
Contraintes - Décalage: 0 m; Hôte: Niveau : Niveau 0; Niveau: Niveau: Niveau 0; Se déplace avec les éléments voisins: no
Cotes - Surface: 141.614 m2; Volume: 23.8504 m3
Graphismes - Branding: yes
Phase de construction - Phase de création: Nouvelle construction
